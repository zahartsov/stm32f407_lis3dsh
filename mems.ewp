# IAR project mems.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407VG ST STM32F407VG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCIncludePath2: .\headers; ..\headers
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: mems.bin
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\ST\stm32f407xG.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: c.srec
  group source
    source/: gpio.c main.c math.c mems.c spi.c system.c tim.c
  group source/CMSIS
    source/CMSIS/: system_stm32f4xx.c
  group source/headers
    source/headers/: core_cm4.h core_cmFunc.h core_cmInstr.h core_cmSimd.h gpio.h math.h mems.h spi.h stm32f4xx.h system.h system_stm32f4xx.h tim.h
  group source/startup
    source/startup/: startup_stm32f40xx.s
